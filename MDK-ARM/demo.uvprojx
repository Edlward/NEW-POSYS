# Keil uVision project demo.uvprojx, settings and files
target ACTION (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\;..\Action_User;..\Libraries\CMSIS;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\MDK-ARM;..\MAA;..\MAA\AHRS;..\MAA\MAA_Driver;..\Libraries\dsplib\Include;..\Libraries\dsplib;..\Action_User\hardware;..\Action_User\baseConfig;..\Action_User\develop;..\Action_User\customer;..\Action_User\math;..\Libraries\dsplib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../Action_User/: main.c stm32f4xx_it.c
    ../Action_User/baseConfig/: icm_20608_g.c
    ../Action_User/develop/: buildExcel.c figureAngle.c figurePos.c temperature_control.c
    ../Action_User/hardware/: gpio.c
    ../Action_User/customer/: receiveData.c sendData.c rotate.c
  group hardware
    ../Action_User/hardware/: flash.c spi.c timer.c usart.c adc.c DataRecover.c iwdg.c odom.c
    ../Action_User/baseConfig/: character.c
  group math
    ../Action_User/math/: leastSquare.c quarternion.c kalman.c self_math.c
    ../Libraries/dsplib/Include/: arm_cortexM4lf_math.lib
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group MDK-ARM
    ../Libraries/CMSIS/startup/: startup_stm32f4xx.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c core_cm4.h
