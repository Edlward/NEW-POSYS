# Keil uVision project ADXRS453test.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: ADXRS453Test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./: startup_ADuCM360.s
  group Application
    ./: ADXRS453test.c ADXRS453.c ADuCM360Driver.c
  group common
    ./: ClkLib.c DioLib.c IntLib.c SpiLib.c UrtLib.c WdtLib.c
